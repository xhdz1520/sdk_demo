# Keil uVision project peripheral_demo.uvproj, settings and files
target peripheral_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: peripheral_demo
  AfterMake: fromelf.exe  --text  -c -o peripheral_demo.txt  Objects/peripheral_demo.axf
  AfterMake: fromelf.exe  --bin -o peripheral_demo.bin  Objects/peripheral_demo.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_ADV_MEM_ALLOOC_NEW,CFG_SIMPLE_PRINTF
  c misc: --preinclude app_config.h
  c include: ..\..\..\..\..\components\driver;..\..\..\..\..\components\driver\include;..\..\..\..\..\components\modules\platform\include;..\..\..\..\..\components\modules\platform\include\cmsis;..\..\..\..\..\components\modules\common\include;..\..\..\..\..\components\ble\include\gap;..\..\..\..\..\components\ble\include\gatt;..\..\..\..\..\components\ble\include\mesh;..\..\..\..\..\components\ble\include;..\..\..\..\..\components\modules\os\include;..\..\..\..\..\components\modules\sys\include;..\..\..\..\..\components\driver\drv_common;..\code
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x800000
  memory RVCT6: RAM 0x20000000 size 0x80000
  memory RVCT7: RAM 0x40000000 size 0x4000
  memory RVCT8: RAM 0x500f8888 size 0x100
  scatter file: ..\..\..\..\..\components\toolchain\armcc\fr800x.sct
  link misc: --feedback=feedback.txt ../../../../../components/ble/library/syscall.txt --entry=app_main --keep=_jump_table_reserved --keep=_jump_table_version --keep=_jump_table_image --keep=_jump_table_middle --keep=_jump_table_last --datacompressor=off
  group application
    ../code/: proj_main.c ota.c usb_ota.c usb_demo.c
    ../../../../../components/driver/: driver_timer.c
  group driver
    ../../../../../components/driver/: driver_pmu.c driver_gpio.c driver_wdt.c usb_core.c usb_dev.c
    ../code/: usb_cdc_ota_transport.c
  group platform
    ../../../../../components/modules/platform/src/keil/: boot_vectors.s
  group lib
    ../../../../../components/ble/library/: fr8000_stack.lib
  group modules
    ../../../../../components/modules/common/src/: co_log.c
